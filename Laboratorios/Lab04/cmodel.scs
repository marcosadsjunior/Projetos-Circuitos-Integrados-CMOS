model cmodel capacitor
